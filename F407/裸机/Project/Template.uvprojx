# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Bsp\Libraries\FWLIB\inc;..\Bsp\Libraries\CORE;..\Bsp\Libraries\SYSTEM;..\Bsp\System\delay;..\Bsp\System\sys;..\Bsp\System\usart;..\Bsp\Libraries\SYSTEM
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../APP/main/: main.c
  group CMSIS
    ../Bsp/Libraries/CORE/: startup_stm32f40_41xxx.s
    ../Bsp/Libraries/SYSTEM/: stm32f4xx_it.c system_stm32f4xx.c
  group Libraries
    ../Bsp/Libraries/FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group System
    ../Bsp/System/delay/: delay.c
    ../Bsp/System/sys/: sys.c
    ../Bsp/System/usart/: usart.c
